# Keil uVision project pd_power_ctrl.uvprojx, settings and files
target PY32F003F18P6_RTOS (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: PY32F003x8 Puya
  pack: Puya.PY32F0xx_DFP.1.2.9
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: pd_power_ctrl +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PY32F003x8,USE_FULL_LL_DRIVER
  c include: ..\Inc;..\..\Logic_PureC;..\..\ExtDev;..\ThirdParty\PY32F0xx_Driver\Inc;..\ThirdParty\PY32F0xx_Driver\CMSIS\Device\Include;..\ThirdParty\PY32F0xx_Driver\CMSIS\Include;..\ThirdParty\FreeRTOS\include;..\ThirdParty\FreeRTOS\portable\RVDS\ARM_CM0
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xff00
  memory RVCT9: RAM 0x20000000 size 0x1fe0
  group Common
    ../Src/: system_py32f0xx.c
    ./: startup_py32f003xx.s
  group App
    ../Src/: main.c py32f0xx_it.c bsp_board.c tft_hud.c
  group Logic_PureC
    ../../Logic_PureC/: pd_sink_policy.c power_pid.c prot_ovp_ocp.c fault_blackbox.c bc1_decode.c
  group ExtDev
    ../../ExtDev/: dev_husb238.c dev_ina226.c
  group Drivers/PY32_LL
    ../ThirdParty/PY32F0xx_Driver/Src/: py32f0xx_ll_utils.c py32f0xx_ll_rcc.c py32f0xx_ll_gpio.c py32f0xx_ll_tim.c py32f0xx_ll_usart.c py32f0xx_ll_i2c.c py32f0xx_ll_exti.c py32f0xx_ll_adc.c py32f0xx_ll_dma.c py32f0xx_ll_spi.c
  group Middlewares/FreeRTOS
    ../ThirdParty/FreeRTOS/: tasks.c queue.c list.c
    ../ThirdParty/FreeRTOS/portable/RVDS/ARM_CM0/: port.c
software components: CMSIS:CORE 5.2.0
